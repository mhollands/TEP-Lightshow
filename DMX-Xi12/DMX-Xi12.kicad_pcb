# Repository mhollands/TEP-Lightshow

File README.MD:

This is the 2016 redesign of the Tau Epsilon Phi, Xi Chapter (MIT) light show. The aim is to have 32 individually addressable 20A wall outlets (on the ceiling). Using the DMX512 protocol, we will be able to turn on, turn off or dim any of the 32 outlets. The DMX signal will come from a PC. The main use of this is to flash the lights in accordance with the current music, via a frequency analysis of the sound, however it will likely also be used for controlling the general lighting in the room, as well as whatever we dream up.

## KiCad design DMX-Xi12/DMX-Xi12.kicad_pcb

Parts:
Con2, Con3, Con4, Con5, Con6, Con7, Con8, Con9, Con10: Screw-terminal

Connections:
/Earth: Con10.3
/Output1/Live1: Con2.1; also elsewhere on the board
/Output1/Live2: Con2.2; also elsewhere on the board
/Output1/Live3: Con2.3; also elsewhere on the board
/Output1/Live4: Con2.4; also elsewhere on the board
/Output1/Live5: Con3.1; also elsewhere on the board
/Output1/Live6: Con3.2; also elsewhere on the board
/Output1/Live7: Con3.3; also elsewhere on the board
/Output1/Live8: Con3.4; also elsewhere on the board
/Output1/Live9: Con4.1; also elsewhere on the board
/Output1/Live10: Con4.2; also elsewhere on the board
/Output1/Live11: Con4.3; also elsewhere on the board
/Output1/Live12: Con4.4; also elsewhere on the board
/Output1/Live13: Con5.1; also elsewhere on the board
/Output1/Live14: Con5.2; also elsewhere on the board
/Output1/Live15: Con5.3; also elsewhere on the board
/Output1/Live16: Con5.4; also elsewhere on the board
/Output1/LiveA: Con10.1; also elsewhere on the board
/Power2/Live17: Con6.1; also elsewhere on the board
/Power2/Live18: Con6.2; also elsewhere on the board
/Power2/Live19: Con6.3; also elsewhere on the board
/Power2/Live20: Con6.4; also elsewhere on the board
/Power2/Live21: Con7.1; also elsewhere on the board
/Power2/Live22: Con7.2; also elsewhere on the board
/Power2/Live23: Con7.3; also elsewhere on the board
/Power2/Live24: Con7.4; also elsewhere on the board
/Power2/Live25: Con8.1; also elsewhere on the board
/Power2/Live26: Con8.2; also elsewhere on the board
/Power2/Live27: Con8.3; also elsewhere on the board
/Power2/Live28: Con8.4; also elsewhere on the board
/Power2/Live29: Con9.1; also elsewhere on the board
/Power2/Live30: Con9.2; also elsewhere on the board
/Power2/Live31: Con9.3; also elsewhere on the board
/Power2/Live32: Con9.4; also elsewhere on the board
/Power/LiveB: Con10.4; also elsewhere on the board
/Power/Neutral: Con10.2; also elsewhere on the board

Parts:
C1, C2: 0.1uF; C_0603
J1, J2: RJ45; RJ45_8
SW1: Switch_SPDT_x2; GS3
U1: MAX13450E; TSSOP-14_4.4x5mm_Pitch0.65mm

Connections:
+5V: C1.1, C2.1, U1.4 (VCC), U1.6 (VL); also elsewhere on the board
/Front-End/RX: U1.3 (DI), U1.7 (RO); also elsewhere on the board
/Front-End/RX_ENABLE: U1.2 (~RE); also elsewhere on the board
/Front-End/TX_ENABLE: U1.1 (DE); also elsewhere on the board
unnamed: J1.1, U1.8 (A)
unnamed: J1.2, U1.9 (~B)
unnamed: J2.1, U1.10 (Y)
unnamed: J2.2, U1.12 (~Z)
unnamed: SW1.2 (B), U1.14 (SRL)

Parts:
C3, C4: 18/39pf; C_0603
C5, C6, C7, C8, C10, C12: 0.01u; C_0603
C9: 1nF; C_0603
Con1: Cortex-10-SWD
D3: LED; LED_0603
D4: D; Diode_DO-41_SOD81_Horizontal_RM10
P3: USB_B; USB_Mini-B
R1, R2: 10; R_0603
R3, R4, R83, R84: 10k; R_0603
R5: 4K7; R_0603
R82: 330R; R_0603
SW2: DIPS_04; SW_DIP_x4_Slide
SW3, SW4: SW_PUSH; SW_TH_Tactile_Omron_B3F-10xx
U2: LPC11U68JBD100E; LQFP-100_14x14mm_Pitch0.5mm
Y1: 12MHz 10/20pf; Crystal_HC49-SD_SMD

Connections:
+5V: D4.1 (K); also elsewhere on the board
/Front-End/RX: U2.17 (PIO0_20); also elsewhere on the board
/Front-End/RX_ENABLE: U2.33 (PIO0_21); also elsewhere on the board
/Front-End/TX_ENABLE: U2.62 (PIO0_22); also elsewhere on the board
/Output1/CH1: U2.35 (PIO1_23); also elsewhere on the board
/Output1/CH2: U2.34 (PIO1_17); also elsewhere on the board
/Output1/CH3: U2.29 (PIO1_20); also elsewhere on the board
/Output1/CH4: U2.28 (PIO1_1); also elsewhere on the board
/Output1/CH5: U2.23 (PIO1_4); also elsewhere on the board
/Output1/CH6: U2.22 (PIO1_27); also elsewhere on the board
/Output1/CH7: U2.20 (PIO1_26); also elsewhere on the board
/Output1/CH8: U2.18 (PIO1_10); also elsewhere on the board
/Output1/CH9: U2.10 (PIO1_7); also elsewhere on the board
/Output1/CH10: U2.4 (PIO1_19); also elsewhere on the board
/Output1/CH11: U2.100 (PIO1_25); also elsewhere on the board
/Output1/CH12: U2.98 (PIO1_6); also elsewhere on the board
/Output1/CH13: U2.97 (PIO1_0); also elsewhere on the board
/Output1/CH14: U2.96 (PIO1_16); also elsewhere on the board
/Output1/CH15: U2.89 (PIO1_12); also elsewhere on the board
/Output1/CH16: U2.87 (PIO1_15); also elsewhere on the board
/Power2/CH17: U2.86 (PIO1_9); also elsewhere on the board
/Power2/CH18: U2.80 (PIO1_22); also elsewhere on the board
/Power2/CH19: U2.79 (PIO1_14); also elsewhere on the board
/Power2/CH20: U2.78 (PIO1_13); also elsewhere on the board
/Power2/CH21: U2.72 (PIO1_3); also elsewhere on the board
/Power2/CH22: U2.67 (PIO1_30); also elsewhere on the board
/Power2/CH23: U2.65 (PIO1_11); also elsewhere on the board
/Power2/CH24: U2.63 (PIO1_29); also elsewhere on the board
/Power2/CH25: U2.61 (PIO1_8); also elsewhere on the board
/Power2/CH26: U2.56 (PIO1_21); also elsewhere on the board
/Power2/CH27: U2.55 (PIO1_2); also elsewhere on the board
/Power2/CH28: U2.48 (PIO1_31); also elsewhere on the board
/Power2/CH29: U2.47 (PIO1_5); also elsewhere on the board
/Power2/CH30: U2.46 (PIO1_28); also elsewhere on the board
/Power2/CH31: U2.43 (PIO1_18); also elsewhere on the board
/Power2/CH32: U2.42 (PIO1_24); also elsewhere on the board
/Power/Zero_crossingA: U2.57 (PIO2_19); also elsewhere on the board
/Power/Zero_crossingB: U2.52 (PIO2_18); also elsewhere on the board
/Processor/RESET: C9.1, Con1.10 (nRESET), R5.2, SW4.1, U2.8 (RESET/PIO0_0)
unnamed: C3.1, U2.12 (PIO2_0), Y1.1
unnamed: C4.1, U2.13 (PIO2_1), Y1.2
unnamed: Con1.2 (SWDIO/TMS), R3.2, U2.81 (SWDIO/PIO0_15)
unnamed: Con1.4 (SWDCLK/TCK), R4.1, U2.60 (SWCLK/PIO0_10)
unnamed: D3.2 (A), R82.2
unnamed: D4.2 (A), P3.1 (VCC), R83.1
unnamed: P3.2 (D-), R1.1
unnamed: P3.3 (D+), R2.1
unnamed: R1.2, U2.38 (USB_DM)
unnamed: R2.2, U2.39 (USB_DP)
unnamed: R82.1, U2.25 (PIO2_12)
unnamed: R83.2, R84.2, U2.30 (PIO0_3)
unnamed: SW2.5, U2.1 (PIO2_23)
unnamed: SW2.6, U2.77 (PIO2_22)
unnamed: SW2.7, U2.76 (PIO2_21)
unnamed: SW2.8, U2.75 (PIO2_20)
unnamed: SW3.1, U2.9 (PIO0_1)

Parts:
C18, C19: 10u; C_0603
Con11: BARREL_JACK
D1, D2: LED; LED_0603
R6, R7, R8, R9, R12, R13, R14, R15: 2k2; R_0603
R10: 390; R_0603
R11, R16: 1k; R_0603
R17: 220; R_0603
U3, U5: LTV-354T; Optocoupler_SMD_HandSoldering_KPC357_LTV35x_PC357_SingleCha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
U4: 7805n

Connections:
+5V: C18.1, Con11.1, R10.1, U4.1 (VI); also elsewhere on the board
/Output1/LiveA: R6.1; also elsewhere on the board
/Power/LiveB: R12.1; also elsewhere on the board
/Power/Neutral: U3.2, U5.2; also elsewhere on the board
/Power/Zero_crossingA: R11.2, U3.4; also elsewhere on the board
/Power/Zero_crossingB: R16.2, U5.4; also elsewhere on the board
unnamed: D1.2 (A), R10.2
unnamed: D2.2 (A), R17.2
unnamed: R6.2, R7.1, U3.1
unnamed: R7.2, R8.1
unnamed: R8.2, R9.1
unnamed: R12.2, R13.1, U5.1
unnamed: R13.2, R14.1
unnamed: R14.2, R15.1

Parts:
R50, R51, R52, R53, R58, R59, R60, R61, R66, R67, R68, R69, R74, R75, R76, R77: 200R; R_0603
R54, R55, R56, R57, R62, R63, R64, R65, R70, R71, R72, R73, R78, R79, R80, R81: 180R; R_0603
U38, U39, U40, U41, U46, U47, U48, U49, U54, U55, U56, U57, U62, U63, U64, U65: AN-3003; DIP-6_W7.62mm_LongPads
U42, U43, U44, U45, U50, U51, U52, U53, U58, U59, U60, U61, U66, U67, U68, U69: BTA20; TO-220

Connections:
/Power2/CH17: R50.2; also elsewhere on the board
/Power2/CH18: R51.2; also elsewhere on the board
/Power2/CH19: R52.2; also elsewhere on the board
/Power2/CH20: R53.2; also elsewhere on the board
/Power2/CH21: R58.2; also elsewhere on the board
/Power2/CH22: R59.2; also elsewhere on the board
/Power2/CH23: R60.2; also elsewhere on the board
/Power2/CH24: R61.2; also elsewhere on the board
/Power2/CH25: R66.2; also elsewhere on the board
/Power2/CH26: R67.2; also elsewhere on the board
/Power2/CH27: R68.2; also elsewhere on the board
/Power2/CH28: R69.2; also elsewhere on the board
/Power2/CH29: R74.2; also elsewhere on the board
/Power2/CH30: R75.2; also elsewhere on the board
/Power2/CH31: R76.2; also elsewhere on the board
/Power2/CH32: R77.2; also elsewhere on the board
/Power2/Live17: R54.1, U42.2 (A2); also elsewhere on the board
/Power2/Live18: R55.1, U43.2 (A2); also elsewhere on the board
/Power2/Live19: R56.1, U44.2 (A2); also elsewhere on the board
/Power2/Live20: R57.1, U45.2 (A2); also elsewhere on the board
/Power2/Live21: R62.1, U50.2 (A2); also elsewhere on the board
/Power2/Live22: R63.1, U51.2 (A2); also elsewhere on the board
/Power2/Live23: R64.1, U52.2 (A2); also elsewhere on the board
/Power2/Live24: R65.1, U53.2 (A2); also elsewhere on the board
/Power2/Live25: R70.1, U58.2 (A2); also elsewhere on the board
/Power2/Live26: R71.1, U59.2 (A2); also elsewhere on the board
/Power2/Live27: R72.1, U60.2 (A2); also elsewhere on the board
/Power2/Live28: R73.1, U61.2 (A2); also elsewhere on the board
/Power2/Live29: R78.1, U66.2 (A2); also elsewhere on the board
/Power2/Live30: R79.1, U67.2 (A2); also elsewhere on the board
/Power2/Live31: R80.1, U68.2 (A2); also elsewhere on the board
/Power2/Live32: R81.1, U69.2 (A2); also elsewhere on the board
/Power/LiveB: U42.1 (A1), U43.1 (A1), U44.1 (A1), U45.1 (A1), U50.1 (A1), U51.1 (A1), U52.1 (A1), U53.1 (A1), U58.1 (A1), U59.1 (A1), U60.1 (A1), U61.1 (A1), U66.1 (A1), U67.1 (A1), U68.1 (A1), U69.1 (A1); also elsewhere on the board
unnamed: R50.1, U38.1 (Anode)
unnamed: R51.1, U39.1 (Anode)
unnamed: R52.1, U40.1 (Anode)
unnamed: R53.1, U41.1 (Anode)
unnamed: R54.2, U38.6 (MAIN_TERM)
unnamed: R55.2, U39.6 (MAIN_TERM)
unnamed: R56.2, U40.6 (MAIN_TERM)
unnamed: R57.2, U41.6 (MAIN_TERM)
unnamed: R58.1, U46.1 (Anode)
unnamed: R59.1, U47.1 (Anode)
unnamed: R60.1, U48.1 (Anode)
unnamed: R61.1, U49.1 (Anode)
unnamed: R62.2, U46.6 (MAIN_TERM)
unnamed: R63.2, U47.6 (MAIN_TERM)
unnamed: R64.2, U48.6 (MAIN_TERM)
unnamed: R65.2, U49.6 (MAIN_TERM)
unnamed: R66.1, U54.1 (Anode)
unnamed: R67.1, U55.1 (Anode)
unnamed: R68.1, U56.1 (Anode)
unnamed: R69.1, U57.1 (Anode)
unnamed: R70.2, U54.6 (MAIN_TERM)
unnamed: R71.2, U55.6 (MAIN_TERM)
unnamed: R72.2, U56.6 (MAIN_TERM)
unnamed: R73.2, U57.6 (MAIN_TERM)
unnamed: R74.1, U62.1 (Anode)
unnamed: R75.1, U63.1 (Anode)
unnamed: R76.1, U64.1 (Anode)
unnamed: R77.1, U65.1 (Anode)
unnamed: R78.2, U62.6 (MAIN_TERM)
unnamed: R79.2, U63.6 (MAIN_TERM)
unnamed: R80.2, U64.6 (MAIN_TERM)
unnamed: R81.2, U65.6 (MAIN_TERM)
unnamed: U38.4 (MAIN_TERM), U42.3 (G)
unnamed: U39.4 (MAIN_TERM), U43.3 (G)
unnamed: U40.4 (MAIN_TERM), U44.3 (G)
unnamed: U41.4 (MAIN_TERM), U45.3 (G)
unnamed: U46.4 (MAIN_TERM), U50.3 (G)
unnamed: U47.4 (MAIN_TERM), U51.3 (G)
unnamed: U48.4 (MAIN_TERM), U52.3 (G)
unnamed: U49.4 (MAIN_TERM), U53.3 (G)
unnamed: U54.4 (MAIN_TERM), U58.3 (G)
unnamed: U55.4 (MAIN_TERM), U59.3 (G)
unnamed: U56.4 (MAIN_TERM), U60.3 (G)
unnamed: U57.4 (MAIN_TERM), U61.3 (G)
unnamed: U62.4 (MAIN_TERM), U66.3 (G)
unnamed: U63.4 (MAIN_TERM), U67.3 (G)
unnamed: U64.4 (MAIN_TERM), U68.3 (G)
unnamed: U65.4 (MAIN_TERM), U69.3 (G)

Parts:
R18, R19, R20, R21, R26, R27, R28, R29, R34, R35, R36, R37, R42, R43, R44, R45: 200R; R_0603
R22, R23, R24, R25, R30, R31, R32, R33, R38, R39, R40, R41, R46, R47, R48, R49: 180R; R_0603
U6, U7, U8, U9, U14, U15, U16, U17, U22, U23, U24, U25, U30, U31, U32, U33: AN-3003; DIP-6_W7.62mm_LongPads
U10, U11, U12, U13, U18, U19, U20, U21, U26, U27, U28, U29, U34, U35, U36, U37: BTA20; TO-220

Connections:
/Output1/CH1: R18.2; also elsewhere on the board
/Output1/CH2: R19.2; also elsewhere on the board
/Output1/CH3: R20.2; also elsewhere on the board
/Output1/CH4: R21.2; also elsewhere on the board
/Output1/CH5: R26.2; also elsewhere on the board
/Output1/CH6: R27.2; also elsewhere on the board
/Output1/CH7: R28.2; also elsewhere on the board
/Output1/CH8: R29.2; also elsewhere on the board
/Output1/CH9: R34.2; also elsewhere on the board
/Output1/CH10: R35.2; also elsewhere on the board
/Output1/CH11: R36.2; also elsewhere on the board
/Output1/CH12: R37.2; also elsewhere on the board
/Output1/CH13: R42.2; also elsewhere on the board
/Output1/CH14: R43.2; also elsewhere on the board
/Output1/CH15: R44.2; also elsewhere on the board
/Output1/CH16: R45.2; also elsewhere on the board
/Output1/Live1: R22.1, U10.2 (A2); also elsewhere on the board
/Output1/Live2: R23.1, U11.2 (A2); also elsewhere on the board
/Output1/Live3: R24.1, U12.2 (A2); also elsewhere on the board
/Output1/Live4: R25.1, U13.2 (A2); also elsewhere on the board
/Output1/Live5: R30.1, U18.2 (A2); also elsewhere on the board
/Output1/Live6: R31.1, U19.2 (A2); also elsewhere on the board
/Output1/Live7: R32.1, U20.2 (A2); also elsewhere on the board
/Output1/Live8: R33.1, U21.2 (A2); also elsewhere on the board
/Output1/Live9: R38.1, U26.2 (A2); also elsewhere on the board
/Output1/Live10: R39.1, U27.2 (A2); also elsewhere on the board
/Output1/Live11: R40.1, U28.2 (A2); also elsewhere on the board
/Output1/Live12: R41.1, U29.2 (A2); also elsewhere on the board
/Output1/Live13: R46.1, U34.2 (A2); also elsewhere on the board
/Output1/Live14: R47.1, U35.2 (A2); also elsewhere on the board
/Output1/Live15: R48.1, U36.2 (A2); also elsewhere on the board
/Output1/Live16: R49.1, U37.2 (A2); also elsewhere on the board
/Output1/LiveA: U10.1 (A1), U11.1 (A1), U12.1 (A1), U13.1 (A1), U18.1 (A1), U19.1 (A1), U20.1 (A1), U21.1 (A1), U26.1 (A1), U27.1 (A1), U28.1 (A1), U29.1 (A1), U34.1 (A1), U35.1 (A1), U36.1 (A1), U37.1 (A1); also elsewhere on the board
unnamed: R18.1, U6.1 (Anode)
unnamed: R19.1, U7.1 (Anode)
unnamed: R20.1, U8.1 (Anode)
unnamed: R21.1, U9.1 (Anode)
unnamed: R22.2, U6.6 (MAIN_TERM)
unnamed: R23.2, U7.6 (MAIN_TERM)
unnamed: R24.2, U8.6 (MAIN_TERM)
unnamed: R25.2, U9.6 (MAIN_TERM)
unnamed: R26.1, U14.1 (Anode)
unnamed: R27.1, U15.1 (Anode)
unnamed: R28.1, U16.1 (Anode)
unnamed: R29.1, U17.1 (Anode)
unnamed: R30.2, U14.6 (MAIN_TERM)
unnamed: R31.2, U15.6 (MAIN_TERM)
unnamed: R32.2, U16.6 (MAIN_TERM)
unnamed: R33.2, U17.6 (MAIN_TERM)
unnamed: R34.1, U22.1 (Anode)
unnamed: R35.1, U23.1 (Anode)
unnamed: R36.1, U24.1 (Anode)
unnamed: R37.1, U25.1 (Anode)
unnamed: R38.2, U22.6 (MAIN_TERM)
unnamed: R39.2, U23.6 (MAIN_TERM)
unnamed: R40.2, U24.6 (MAIN_TERM)
unnamed: R41.2, U25.6 (MAIN_TERM)
unnamed: R42.1, U30.1 (Anode)
unnamed: R43.1, U31.1 (Anode)
unnamed: R44.1, U32.1 (Anode)
unnamed: R45.1, U33.1 (Anode)
unnamed: R46.2, U30.6 (MAIN_TERM)
unnamed: R47.2, U31.6 (MAIN_TERM)
unnamed: R48.2, U32.6 (MAIN_TERM)
unnamed: R49.2, U33.6 (MAIN_TERM)
unnamed: U6.4 (MAIN_TERM), U10.3 (G)
unnamed: U7.4 (MAIN_TERM), U11.3 (G)
unnamed: U8.4 (MAIN_TERM), U12.3 (G)
unnamed: U9.4 (MAIN_TERM), U13.3 (G)
unnamed: U14.4 (MAIN_TERM), U18.3 (G)
unnamed: U15.4 (MAIN_TERM), U19.3 (G)
unnamed: U16.4 (MAIN_TERM), U20.3 (G)
unnamed: U17.4 (MAIN_TERM), U21.3 (G)
unnamed: U22.4 (MAIN_TERM), U26.3 (G)
unnamed: U23.4 (MAIN_TERM), U27.3 (G)
unnamed: U24.4 (MAIN_TERM), U28.3 (G)
unnamed: U25.4 (MAIN_TERM), U29.3 (G)
unnamed: U30.4 (MAIN_TERM), U34.3 (G)
unnamed: U31.4 (MAIN_TERM), U35.3 (G)
unnamed: U32.4 (MAIN_TERM), U36.3 (G)
unnamed: U33.4 (MAIN_TERM), U37.3 (G)

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
Board: 2 copper layers, 177.8 x 196.8 mm, 183 parts (0 on the bottom side), 198 nets.

## Commit log

2016-01-30 started schematics for DMX-Xi12 slave board
2016-02-02 finished input stage and started work on processor stage
2016-02-06 added output stage
2016-02-22 more schematic
2016-02-22 changed processor to 3.3v and added programming
2016-02-28 made dlaw changes etc
2016-04-04 working on pcb
2016-04-04 more work on board
2016-05-07 completed board. Schematic, is correct but some part values and numbers need updating! Do not trust the schematic yet
2016-05-07 added PDF of final board layout
2016-05-07 Added readme
